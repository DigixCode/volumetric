# Keil uVision project volumetric.uvprojx, settings and files
target volumetric (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MAX32620 Maxim
  pack: Maxim.MAX32620.0.0.0-1.alpha
  cpu: IRAM(0x20000000,0x00028000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: volumetric +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: TARGET=MAX32620 TARGET_REV=0x4132 MAX35103
  c include: ..;..\board\max35103evkit2\csl\CMSIS\Include;..\board\max35103evkit2\csl\CMSIS\Device\Maxim\MAX32620\Include;..\board\max35103evkit2\csl\PeriphDriver\Include;..\board\max35103evkit2\max3510x;..\board\max35103evkit2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  group csl
    ../board/max35103evkit2/csl/CMSIS/Device/Maxim/MAX32620/Source/: system_max32620.c
    ../board/max35103evkit2/csl/CMSIS/Device/Maxim/MAX32620/Source/ARM/: startup_max32620.s
    ../board/max35103evkit2/csl/PeriphDriver/Source/: adc.c aes.c clkman.c crc.c flc.c gpio.c i2cm.c i2cs.c icc.c ioman.c lp.c maa.c mxc_assert.c mxc_sys.c nvic_table.c owm.c pmu.c prng.c pt.c rtc.c spim.c spis.c spix.c tmr.c tmr_utils.c uart.c wdt.c wdt2.c mxc_lock.c
  group src
    ../: main.c global.h
  group max3510x
    ../board/max35103evkit2/max3510x/: max3510x.c
  group board
    ../board/max35103evkit2/: transducer.c board.c
